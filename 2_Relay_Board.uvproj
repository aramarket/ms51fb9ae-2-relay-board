# Keil uVision project 2_Relay_Board.uvproj, settings and files
target 2_Relay_Board (MCS-51)
  device: MS51xB9xE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: 2_Relay_Board +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Header;.\StdDriver\inc
  group Main
    ./Code/: main.c adc.c seven_segment_cc.c
